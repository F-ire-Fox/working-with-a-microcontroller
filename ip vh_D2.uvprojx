# Keil uVision project ip vh_D2.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: GD32E230K8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: ip vh_D2 +hex
  BeforeMake: .\getUtime.bat
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: GD32E230
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: drv_ADC.c drv_ADC.h drv_time.c drv_time.h drv_uart.c drv_uart.h main.c timestamp.h UARTRoutine.c UARTRoutine.h crc8_CCITT.c crc8_CCITT.h drv_FreqMet.c drv_FreqMet.h
software components: CMSIS:CORE 5.6.0, Device:GD32E23x_StdPeripherals:ADC 1.0.0, Device:GD32E23x_StdPeripherals:CRC 1.0.0, Device:GD32E23x_StdPeripherals:DMA 1.0.0, Device:GD32E23x_StdPeripherals:FMC 1.0.0, Device:GD32E23x_StdPeripherals:GPIO 1.0.0, Device:GD32E23x_StdPeripherals:MISC 1.0.0, Device:GD32E23x_StdPeripherals:RCU 1.0.0, Device:GD32E23x_StdPeripherals:SYSCFG 1.0.0, Device:GD32E23x_StdPeripherals:TIMER 1.0.0, Device:GD32E23x_StdPeripherals:USART 1.0.0, Device:GD32E23x_libopt 1.0.0, Device:Startup 1.0.0
